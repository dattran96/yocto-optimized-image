FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://exfat.cfg"
